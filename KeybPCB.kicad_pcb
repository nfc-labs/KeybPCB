# Repository nfc-labs/KeybPCB

## KiCad design KeybPCB.kicad_pcb

Parts:
C1: 10uF
C2, C3: 10pF
D0:0, D0:1, D0:2, D0:6, D0:10, D0:11, D0:12, D0:13, D0:14, D1:0, D1:3, D1:4, D1:5, D1:6, D1:7, D1:8, D1:9, D1:10, D1:11, D1:12, D1:13, D1:14, D2:0, D2:1, D2:2, D2:3, D2:4, D2:5, D2:6, D2:7, D2:8, D2:9, D2:10, D2:11, D2:13, D2:14, D3:0, D3:1, D3:2, D3:3, D3:4, D3:5, D3:6, D3:7, D3:8, D3:9, D3:10, D3:11, D3:12, D3:13, D3:14, D4:0, D4:1, D4:2, D4:3, D4:4, D4:5, D4:6, D4:7, D4:8, D4:9, D4:10, D4:11, D4:12, D4:13, D4:14: D
D:1:2: D
P1, P2, P3, P4, P5, P6: PAD
R1, R2: 22
R3: 1K
SW0:0: L.CTRL
SW0:1: FN
SW0:2: L.ALT
SW0:6: SPACE
SW0:10: R.ALT
SW0:11: R.CTRL
SW0:12: LEFT
SW0:13: DOWN
SW0:14: RIGHT
SW1:0, SW1:12: L.SHIFT
SW1:2: Z
SW1:3: X
SW1:4: C
SW1:5: V
SW1:6: B
SW1:7: N
SW1:8: M
SW1:9: ,
SW1:10: .
SW1:11: /
SW1:13: UP
SW1:14: PAUSE
SW2:0: SH.LK
SW2:1: A
SW2:2: S
SW2:3: D
SW2:4: F
SW2:5: G
SW2:6: H
SW2:7: J
SW2:8: K
SW2:9: L
SW2:10: :
SW2:11: APOS
SW2:13: RET
SW2:14: PRINT
SW3:0: TAB
SW3:1: Q
SW3:2: W
SW3:3: E
SW3:4: R
SW3:5: T
SW3:6: Y
SW3:7: U
SW3:8: I
SW3:9: O
SW3:10: P
SW3:11: [
SW3:12: ]
SW3:13: \\
SW3:14: DEL
SW4:0: TILDE
SW4:1: 1
SW4:2: 2
SW4:3: 3
SW4:4: 4
SW4:5: 5
SW4:6: 6
SW4:7: 7
SW4:8: 8
SW4:9: 9
SW4:10: 0
SW4:11: -
SW4:12: =
SW4:13: BK.SP
SW4:14: INS
U1: ATMEGA32U4_TQFP44
X1: MINI-USB
X2: CRYSTAL

Connections:
/COL0: D0:0.2 (B), D1:0.2 (B), D2:0.2 (B), D3:0.2 (B), D4:0.2 (B), U1.36
/COL1: D0:1.2 (B), D2:1.2 (B), D3:1.2 (B), D4:1.2 (B), U1.37
/COL2: D0:2.2 (B), D2:2.2 (B), D3:2.2 (B), D4:2.2 (B), D:1:2.2 (B), U1.38
/COL3: D1:3.2 (B), D2:3.2 (B), D3:3.2 (B), D4:3.2 (B), U1.39
/COL4: D1:4.2 (B), D2:4.2 (B), D3:4.2 (B), D4:4.2 (B), U1.40
/COL5: D1:5.2 (B), D2:5.2 (B), D3:5.2 (B), D4:5.2 (B), U1.41
/COL6: D0:6.2 (B), D1:6.2 (B), D2:6.2 (B), D3:6.2 (B), D4:6.2 (B), U1.42
/COL7: D1:7.2 (B), D2:7.2 (B), D3:7.2 (B), D4:7.2 (B), U1.2
/COL8: D1:8.2 (B), D2:8.2 (B), D3:8.2 (B), D4:8.2 (B), U1.3
/COL9: D1:9.2 (B), D2:9.2 (B), D3:9.2 (B), D4:9.2 (B), U1.4
/COL10: D0:10.2 (B), D1:10.2 (B), D2:10.2 (B), D3:10.2 (B), D4:10.2 (B), U1.5
/COL11: D0:11.2 (B), D1:11.2 (B), D2:11.2 (B), D3:11.2 (B), D4:11.2 (B), U1.6
/COL12: D0:12.2 (B), D1:12.2 (B), D3:12.2 (B), D4:12.2 (B), U1.7
/COL13: D0:13.2 (B), D1:13.2 (B), D2:13.2 (B), D3:13.2 (B), D4:13.2 (B), U1.8
/COL14: D0:14.2 (B), D1:14.2 (B), D2:14.2 (B), D3:14.2 (B), D4:14.2 (B), U1.9
/D+: R1.2 (B), X1.3
/D-: R2.2 (B), X1.2
/MISO: P2.1, U1.23
/MOSI: P4.1, U1.24
/ROW0: SW0:0.1 (A), SW0:1.1 (A), SW0:2.1 (A), SW0:6.1 (A), SW0:10.1 (A), SW0:11.1 (A), SW0:12.1 (A), SW0:13.1 (A), SW0:14.1 (A), U1.16
/ROW1: SW1:0.1 (A), SW1:2.1 (A), SW1:3.1 (A), SW1:4.1 (A), SW1:5.1 (A), SW1:6.1 (A), SW1:7.1 (A), SW1:8.1 (A), SW1:9.1 (A), SW1:10.1 (A), SW1:11.1 (A), SW1:12.1 (A), SW1:13.1 (A), SW1:14.1 (A), U1.15
/ROW2: SW2:0.1 (A), SW2:1.1 (A), SW2:2.1 (A), SW2:3.1 (A), SW2:4.1 (A), SW2:5.1 (A), SW2:6.1 (A), SW2:7.1 (A), SW2:8.1 (A), SW2:9.1 (A), SW2:10.1 (A), SW2:11.1 (A), SW2:13.1 (A), SW2:14.1 (A), U1.14
/ROW3: SW3:0.1 (A), SW3:1.1 (A), SW3:2.1 (A), SW3:3.1 (A), SW3:4.1 (A), SW3:5.1 (A), SW3:6.1 (A), SW3:7.1 (A), SW3:8.1 (A), SW3:9.1 (A), SW3:10.1 (A), SW3:11.1 (A), SW3:12.1 (A), SW3:13.1 (A), SW3:14.1 (A), U1.13
/ROW4: SW4:0.1 (A), SW4:1.1 (A), SW4:2.1 (A), SW4:3.1 (A), SW4:4.1 (A), SW4:5.1 (A), SW4:6.1 (A), SW4:7.1 (A), SW4:8.1 (A), SW4:9.1 (A), SW4:10.1 (A), SW4:11.1 (A), SW4:12.1 (A), SW4:13.1 (A), SW4:14.1 (A), U1.12
/SCLK: P3.1, U1.25
/VCC: P1.1, U1.32, X1.1
/~RST~: P5.1, U1.21
GND: C1.2, C2.2, C3.2, P6.1, R3.1 (A), U1.11, U1.19, U1.29, U1.35, U1.43, X1.5
unnamed: D4:9.1 (A), SW4:9.2 (B)
unnamed: D1:9.1 (A), SW1:9.2 (B)
unnamed: D3:9.1 (A), SW3:9.2 (B)
unnamed: D2:9.1 (A), SW2:9.2 (B)
unnamed: D4:8.1 (A), SW4:8.2 (B)
unnamed: D1:8.1 (A), SW1:8.2 (B)
unnamed: D3:8.1 (A), SW3:8.2 (B)
unnamed: D2:8.1 (A), SW2:8.2 (B)
unnamed: D3:11.1 (A), SW3:11.2 (B)
unnamed: D4:11.1 (A), SW4:11.2 (B)
unnamed: D1:11.1 (A), SW1:11.2 (B)
unnamed: D0:11.1 (A), SW0:11.2 (B)
unnamed: D2:11.1 (A), SW2:11.2 (B)
unnamed: D4:10.1 (A), SW4:10.2 (B)
unnamed: D1:10.1 (A), SW1:10.2 (B)
unnamed: D0:10.1 (A), SW0:10.2 (B)
unnamed: D3:10.1 (A), SW3:10.2 (B)
unnamed: D2:10.1 (A), SW2:10.2 (B)
unnamed: D4:5.1 (A), SW4:5.2 (B)
unnamed: D3:4.1 (A), SW3:4.2 (B)
unnamed: D2:4.1 (A), SW2:4.2 (B)
unnamed: D1:5.1 (A), SW1:5.2 (B)
unnamed: D3:5.1 (A), SW3:5.2 (B)
unnamed: D2:5.1 (A), SW2:5.2 (B)
unnamed: D3:3.1 (A), SW3:3.2 (B)
unnamed: D2:3.1 (A), SW2:3.2 (B)
unnamed: D4:4.1 (A), SW4:4.2 (B)
unnamed: D1:4.1 (A), SW1:4.2 (B)
unnamed: D4:7.1 (A), SW4:7.2 (B)
unnamed: D1:7.1 (A), SW1:7.2 (B)
unnamed: D3:7.1 (A), SW3:7.2 (B)
unnamed: D2:7.1 (A), SW2:7.2 (B)
unnamed: D1:6.1 (A), SW1:6.2 (B)
unnamed: D4:6.1 (A), SW4:6.2 (B)
unnamed: D0:6.1 (A), SW0:6.2 (B)
unnamed: D3:6.1 (A), SW3:6.2 (B)
unnamed: D2:6.1 (A), SW2:6.2 (B)
unnamed: C1.1, U1.28
unnamed: R3.2 (B), U1.1
unnamed: R1.1 (A), U1.30
unnamed: R2.1 (A), U1.31
unnamed: U1.10, U1.20, U1.27, U1.34, U1.44
unnamed: D3:13.1 (A), SW3:13.2 (B)
unnamed: D4:13.1 (A), SW4:13.2 (B)
unnamed: D1:13.1 (A), SW1:13.2 (B)
unnamed: D0:13.1 (A), SW0:13.2 (B)
unnamed: D2:13.1 (A), SW2:13.2 (B)
unnamed: D0:12.1 (A), SW0:12.2 (B)
unnamed: D4:12.1 (A), SW4:12.2 (B)
unnamed: D1:12.1 (A), SW1:12.2 (B)
unnamed: D3:12.1 (A), SW3:12.2 (B)
unnamed: D4:14.1 (A), SW4:14.2 (B)
unnamed: D1:14.1 (A), SW1:14.2 (B)
unnamed: D0:14.1 (A), SW0:14.2 (B)
unnamed: D3:14.1 (A), SW3:14.2 (B)
unnamed: D2:14.1 (A), SW2:14.2 (B)
unnamed: D3:1.1 (A), SW3:1.2 (B)
unnamed: D4:1.1 (A), SW4:1.2 (B)
unnamed: D0:1.1 (A), SW0:1.2 (B)
unnamed: D2:1.1 (A), SW2:1.2 (B)
unnamed: D4:2.1 (A), SW4:2.2 (B)
unnamed: D3:0.1 (A), SW3:0.2 (B)
unnamed: D4:0.1 (A), SW4:0.2 (B)
unnamed: D1:0.1 (A), SW1:0.2 (B)
unnamed: D0:0.1 (A), SW0:0.2 (B)
unnamed: D:1:2.1 (A), SW1:2.2 (B)
unnamed: D2:0.1 (A), SW2:0.2 (B)
unnamed: D0:2.1 (A), SW0:2.2 (B)
unnamed: D3:2.1 (A), SW3:2.2 (B)
unnamed: D2:2.1 (A), SW2:2.2 (B)
unnamed: D4:3.1 (A), SW4:3.2 (B)
unnamed: D1:3.1 (A), SW1:3.2 (B)
unnamed: C3.1, U1.17, X2.1
unnamed: C2.1, U1.18, X2.2

Board: 2 copper layers, 285.0 x 95.0 mm, 155 parts (9 on the bottom side), 102 nets.

Other parts of the board:
HOLE1, HOLE2, HOLE3, HOLE4, HOLE5, HOLE6: Hole3mm

## Commit log

2013-04-14 2nd commit
